# Keil uVision project atk_f407.uvprojx, settings and files
target TEST (5060960::V5.06 update 7 (build 960)::.\Installer)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx,USE_USB_FS
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Middlewares;..\..\User;..\..\User\APP;..\..\Middlewares\GUI;..\..\Middlewares\NES;..\..\Middlewares\SMS;..\..\Middlewares\AUDIOCODEC\wav;..\..\Middlewares\AUDIOCODEC\flac;..\..\Middlewares\AUDIOCODEC\flac\flacdec;..\..\Middlewares\AUDIOCODEC\mp3;..\..\Middlewares\AUDIOCODEC\mp3\helix;..\..\Middlewares\AUDIOCODEC\ape;..\..\Middlewares\AUDIOCODEC\ape\apedec;..\..\Middlewares\NES;..\..\Middlewares\SMS;..\..\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Class\HID\Inc;..\..\Middlewares\USB\STM32_USB_Host_Library\Class\MSC\Inc;..\..\Middlewares\USB\USB_APP;..\..\Middlewares\USB\USB_HAL;..\..\Middlewares\LWIP;..\..\Middlewares\LWIP\arch;..\..\Middlewares\LWIP\lwip-1.4.1\src\include;..\..\Middlewares\LWIP\lwip-1.4.1\src\include\ipv4;..\..\Middlewares\LWIP\lwip-1.4.1\src\include\lwip;..\..\Middlewares\LWIP\lwip-1.4.1\src\include\netif;..\..\Middlewares\LWIP\lwip_app\lwip_comm;..\..\Middlewares\LWIP\lwip_app\tcp_server_demo;..\..\Middlewares\LWIP\lwip_app\udp_demo;..\..\Middlewares\LWIP\lwip_app\web_server_demo;..\..\Middlewares\UCOSII\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\UCOSII\uC-CPU\Cfg\Template;..\..\Middlewares\UCOSII\uC-CPU;..\..\Middlewares\UCOSII\uC-LIB\Cfg\Template;..\..\Middlewares\UCOSII\uC-LIB;..\..\Middlewares\UCOSII\uC-OS2\Cfg\Template;..\..\Middlewares\UCOSII\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\UCOSII\uC-OS2\Source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c
  group USER/APP
    ../../User/APP/: spb.c common.c ebook.c picviewer.c audioplay.c lyric.c videoplay.c calendar.c settings.c nesplay.c notepad.c exeplay.c phoneplay.c paint.c camera.c recorder.c usbplay.c netplay.c wirelessplay.c calculator.c vmeterplay.c appplay.c appplay_remote.c appplay_compass.c keyplay.c ledplay.c beepplay.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/SDIO/: sdio_sdcard.c
    ../../Drivers/BSP/TPAD/: tpad.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/NORFLASH/: norflash.c
    ../../Drivers/BSP/I2S/: i2s.c
    ../../Drivers/BSP/ES8388/: es8388.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/USART3/: usart3.c
    ../../Drivers/BSP/GSM/: gsm.c
    ../../Drivers/BSP/TIMER/: timer.c
    ../../Drivers/BSP/SPBLCD/: spblcd.c
    ../../Drivers/BSP/REMOTE/: remote.c
    ../../Drivers/BSP/RTC/: rtc.c
    ../../Drivers/BSP/DS18B20/: ds18b20.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../../Drivers/BSP/ADC/: adc.c adc3.c
    ../../Drivers/BSP/LSENS/: lsens.c
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/DMA/: dma.c
    ../../Drivers/BSP/OV2640/: ov2640.c sccb.c
    ../../Drivers/BSP/DCMI/: dcmi.c
    ../../Drivers/BSP/ETHERNET/: ethernet.c stm32f4x7_eth.c
    ../../Drivers/BSP/NRF24L01/: nrf24l01.c
    ../../Drivers/BSP/ST480MC/: st480mc.c
    ../../Drivers/BSP/QMA6100P/: qma6100p.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/USMART
    ../../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group Middlewares/FATFS
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
  group Middlewares/PICTURE
    ../../Middlewares/PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group Middlewares/TEXT
    ../../Middlewares/TEXT/: fonts.c text.c
  group Middlewares/GUI
    ../../Middlewares/GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group Middlewares/uC-OS2/BSP
    ../../Middlewares/UCOSII/uC-CPU/BSP/Template/: bsp_cpu.c
  group Middlewares/uC-OS2/CPU
    ../../Middlewares/UCOSII/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../../Middlewares/UCOSII/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/UCOSII/uC-CPU/: cpu_core.c
  group Middlewares/uC-OS2/LIB
    ../../Middlewares/UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS2/OS2
    ../../Middlewares/UCOSII/uC-OS2/Cfg/Template/: app_hooks.c
    ../../Middlewares/UCOSII/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm os_dbg.c
    ../../Middlewares/UCOSII/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/UCOSII/uC-OS2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Middlewares/AUDIOCODEC/WAV
    ../../Middlewares/AUDIOCODEC/wav/: wavplay.c
  group Middlewares/AUDIOCODEC/MP3
    ../../Middlewares/AUDIOCODEC/mp3/: mp3play.c
    ../../Middlewares/AUDIOCODEC/mp3/helix/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3dec.c mp3tabs.c scalfact.c stproc.c subband.c trigtabs.c
    ../../Middlewares/AUDIOCODEC/mp3/helix/arm/: asmmisc_rvds.s asmpoly_thumb2_rvds.s
  group Middlewares/AUDIOCODEC/FLAC
    ../../Middlewares/AUDIOCODEC/flac/: flacplay.c
    ../../Middlewares/AUDIOCODEC/flac/flacdec/: bitstreamf.c flacdecoder.c tables.c
  group Middlewares/AUDIOCODEC/APE
    ../../Middlewares/AUDIOCODEC/ape/: apeplay.c
    ../../Middlewares/AUDIOCODEC/ape/apedec/: apedecoder.c entropy.c filter_16_11.c filter_32_10.c filter_64_11.c parser.c predictor.c predictor-arm.S
  group Middlewares/MJPEG
    ../../Middlewares/MJPEG/: avi.c mjpeg.c
    ../../Middlewares/MJPEG/JPEG/: jaricom.c jcomapi.c jutils.c jerror.c jmemmgr.c jdapimin.c jdapistd.c jdarith.c jdmaster.c jdinput.c jdmarker.c jdhuff.c jdmainct.c jdcoefct.c jdpostct.c jddctmgr.c jidctflt.c jidctfst.c jidctint.c jdsample.c jdcolor.c jquant1.c jquant2.c jdmerge.c jmemnobs.c wrppm.c
  group Middlewares/NES
    ../../Middlewares/NES/: nes_apu.c nes_crc32.c nes_main.c nes_mapper.c nes_ppu.c 6502.s
  group Middlewares/USB_CORE
    ../../Middlewares/USB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares/USB_CLASS
    ../../Middlewares/USB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../../Middlewares/USB/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid.c usbh_hid_keybd.c usbh_hid_mouse.c usbh_hid_parser.c usbh_hid_gamepad.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares/USB_HAL
    ../../Middlewares/USB/USB_HAL/: stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Middlewares/USB_APP
    ../../Middlewares/USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_storage.c usbh_conf.c usbh_diskio.c usb_app.c
  group Middlewares/T9INPUT
    ../../Middlewares/T9INPUT/: pyinput.c t9input.c
  group Middlewares/ATKNCR
    ../../Middlewares/ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group Middlewares/LWIP/src/core
    ../../Middlewares/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../Middlewares/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group Middlewares/LWIP/src/api
    ../../Middlewares/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/LWIP/src/netif
    ../../Middlewares/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group Middlewares/LWIP/arch
    ../../Middlewares/LWIP/arch/: sys_arch.c
  group Middlewares/LWIP/lwip_app
    ../../Middlewares/LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../../Middlewares/LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
  group Readme
    ../../: readme.txt
